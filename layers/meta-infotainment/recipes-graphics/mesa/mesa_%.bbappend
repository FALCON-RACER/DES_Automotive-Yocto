EXTRA_OEMESON:append = " \
        -Dplatforms=wayland \
        -Degl=enabled \
        -Dgbm=enabled \
        -Dgles1=enabled \
        -Dgles2=enabled \
        -Dgallium-drivers=kmsro,v3d,vc4 \
"
